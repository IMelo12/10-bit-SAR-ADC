v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ff.sym} 0 -30 0 0 {name=x1}
C {ff.sym} 300 -30 0 0 {name=x2}
