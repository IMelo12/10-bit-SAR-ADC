v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {bootstrapped_switch/bsswitch.sym} -130 -130 0 0 {name=x1}
C {comparator/preamp_comparator.sym} -50 100 0 0 {name=x2}
C {dac/dac.sym} -130 -20 0 0 {name=x3}
C {devices/ipin.sym} -690 -150 0 0 {name=p195 lab=vin_n
}
C {devices/ipin.sym} -690 30 0 0 {name=p197 lab=comp_clk
}
C {devices/ipin.sym} -690 -130 0 0 {name=p36 lab=sw_sample
}
C {devices/ipin.sym} -690 -170 0 0 {name=p35 lab=vin_p
}
C {devices/iopin.sym} -630 -120 0 0 {name=p199 lab=VDD}
C {devices/iopin.sym} -630 -100 0 0 {name=p200 lab=GND}
C {devices/opin.sym} -630 -170 0 0 {name=p44 lab=comp_p}
C {devices/opin.sym} -630 -150 0 0 {name=p45 lab=comp_n}
C {devices/lab_pin.sym} -280 -170 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -280 -150 0 0 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -280 -130 0 0 {name=p11 sig_type=std_logic lab=vin_p}
C {devices/lab_pin.sym} -280 -110 0 0 {name=p12 sig_type=std_logic lab=vin_n}
C {devices/lab_pin.sym} -280 -90 0 0 {name=p13 sig_type=std_logic lab=sw_sample}
C {devices/lab_pin.sym} 20 -170 0 1 {name=p14 sig_type=std_logic lab=vsample_p}
C {devices/lab_pin.sym} 20 -150 0 1 {name=p15 sig_type=std_logic lab=vsample_n}
C {devices/lab_pin.sym} -280 -30 0 0 {name=p19 sig_type=std_logic lab=sw_p_sp[9..1]}
C {devices/lab_pin.sym} -280 -50 0 0 {name=p20 sig_type=std_logic lab=sw_n_sp[9..1]}
C {devices/lab_pin.sym} -280 10 0 0 {name=p26 sig_type=std_logic lab=sw_p[8..1]}
C {devices/lab_pin.sym} -280 -10 0 0 {name=p27 sig_type=std_logic lab=sw_n[8..1]}
C {devices/lab_pin.sym} 20 -50 0 1 {name=p18 sig_type=std_logic lab=vsample_p}
C {devices/lab_pin.sym} 20 -30 0 1 {name=p21 sig_type=std_logic lab=vsample_n}
C {devices/lab_pin.sym} 20 -10 0 1 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 20 10 0 1 {name=p2 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 60 0 1 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -130 140 0 1 {name=p5 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -200 80 0 0 {name=p16 sig_type=std_logic lab=vsample_p}
C {devices/lab_pin.sym} -200 120 0 0 {name=p17 sig_type=std_logic lab=vsample_n}
C {devices/lab_pin.sym} -200 100 0 0 {name=p39 sig_type=std_logic lab=comp_clk}
C {devices/lab_pin.sym} -50 90 0 1 {name=p22 sig_type=std_logic lab=comp_p}
C {devices/lab_pin.sym} -50 110 0 1 {name=p6 sig_type=std_logic lab=comp_n}
C {devices/ipin.sym} -690 -70 0 0 {name=p8 lab=sw_sp_n[9..1]
}
C {devices/ipin.sym} -690 -50 0 0 {name=p9 lab=sw_sp_p[9..1]
}
C {devices/ipin.sym} -690 -30 0 0 {name=p82 lab=sw_n[8..1]
}
C {devices/ipin.sym} -690 -10 0 0 {name=p83 lab=sw_p[8..1]
}
